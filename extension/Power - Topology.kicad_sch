File: extension/Power - Topology.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: First version of the Layout and the Schematics is done
Other:
- company: (none) -> ${COMPANY}
